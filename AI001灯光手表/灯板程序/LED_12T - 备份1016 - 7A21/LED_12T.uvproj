# Keil uVision project LED_12T.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LED_12T +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;.\head;.\Common;.\LIB
  group Common
    ./Common/: IO_conf.h SFR_Macro.h STARTUP.A51 System.c
    ./head/: config.h
  group Source
    ./Code/: main.c adc.c eeprom.c Work.c UART.C SC7A21.c i2c_software.c SL_Watch_Pedo_Application.c iic.c
  group LIB
    ./LIB/: SL_Watch_Pedo_Algorithm.lib
