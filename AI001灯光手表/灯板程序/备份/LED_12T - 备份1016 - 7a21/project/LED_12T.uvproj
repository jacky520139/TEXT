# Keil uVision project LED_12T.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LED_12T +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\lib;..\Common;..\head
  asm include: ..\Common
  group Startup
    ../Common/: STARTUP.A51
  group Common
    ../Common/: System.c
  group Source
    ../Code/: adc.c eeprom.c i2c_software.c iic.c main.c SC7A21.c SL_Watch_Pedo_Application.c UART.C Work.c
  group LIB
    ../lib/: SL_Watch_Pedo_Algorithm.lib
