# Keil uVision project LED_12T.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LED_12T +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Common;..\head
  group Startup
    ../Common/: STARTUP.A51
  group Common
    ../Common/: System.c IO_conf.h SFR_Macro.h
  group Source
    ../Code/: main.c adc.c eeprom.c i2c_software.c registers.c SC7A21.c UART.C Work.c SL_Sc7a21_Driver.c SL_SC7A21_Application.c
